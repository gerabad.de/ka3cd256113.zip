Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: x:/temp/worker_COMMON_87/temp/tmp_5536_73_31TAa/format_1/Mod. 1021 1650x710 FertRoh(architecture=300).ifc
Time: 2025-09-03T09:27:36
Made in: PARTsolutions

# IfcDiscreteAccessory, Mod. 1021 1650x710 FertRoh(architecture=300)
In: BUILDING
Description: Mod. 1021 1650x710 FertRoh(architecture=300)
Pset_ManufacturerTypeInformation - Manufacturer: KALDEWEI; ArticleNumber: Mod. 1021 1650x710 FertRoh
ePset_PARTsolutions - NB: Mod. 1021 1650x710 FertRoh(architecture=300); NN: Mod. 1021 1650x710 FertRoh; NBSYN: $A.($LODDEST.=$LODLEVEL.); LINA: Mod. 1021 1650x710 FertRoh(architecture=300); CATALOG: Kaldewei; LODLEVEL: 300; A: Mod. 1021 1650x710 FertRoh; B: mod_1021_1650x710_fertroh.png; E: KALDEWEI
